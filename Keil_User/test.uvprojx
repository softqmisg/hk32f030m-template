# Keil uVision project test.uvprojx, settings and files
target Target 1 (6150000::V6.15::ARMCLANG)
  device: HK32F030MF4P6 HK_MicroChip
  pack: HKMicroChip.HK32F030xMxx_DFP.1.0.17
  cpu: IRAM(0x20000000,0x800) IROM(0x08000000,0x4000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: test +hex
  c flags: Optim=4 OneElfS=1 v6Lang=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,HK32F030MF4P6
  c include: ..\Keil_User;..\Libraries\CMSIS\Core\Include;..\Libraries\CMSIS\HK32F030M\Include;..\Libraries\HK32F030M_Driver\inc;..\Libraries\Debug;..\User
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x800
  scatter file: .\Objects\test.sct
  group CMSIS
    ../Libraries/CMSIS/HK32F030M/Source/: startup_hk32f030mf4p6.s system_hk32f030m.c
  group UserApplication
    ../User/: main.c hk32f030m_it.c
    ../Libraries/Debug/: systick_delay.c
    ./: test
  group HK32F030M_Driver
    ../Libraries/HK32F030M_Driver/src/: hk32f030m_adc.c hk32f030m_awu.c hk32f030m_beep.c hk32f030m_crc.c hk32f030m_dbgmcu.c hk32f030m_exti.c hk32f030m_flash.c hk32f030m_gpio.c hk32f030m_i2c.c hk32f030m_iwdg.c hk32f030m_misc.c hk32f030m_pwr.c hk32f030m_rcc.c hk32f030m_spi.c hk32f030m_syscfg.c hk32f030m_tim.c hk32f030m_usart.c hk32f030m_wwdg.c
software components: CMSIS:CORE 5.5.0, Device:Startup 1.0.0
